FILESEXTRAPATHS_append := ":${THISDIR}/files"

SRC_URI_append = " \
    file://dnsmasq.conf \
    "